FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://u-boot-fpgaload.patch"
